# Repository pyr0ball/pyr0piezo (continued)

## EAGLE design Hardware/Eagle_Files/EzPzEffector/EzPz-Effector_v2.3.1.brd (continued)

Board: 2 copper layers, 90.2 x 85.9 mm, 68 parts (17 on the bottom side), 44 nets.

Other parts of the board:
BYPASS: C-GRID-02-70543; 70543-02
U$1: LOGO-PYR0BALL-SS-20MM
U$2, U$3, U$4: LOGO-PYR0BALL-SS-6MM
U$5, U$6: OSHW_8MM

Their connections:
VCC_REG: BYPASS.2; also elsewhere on the board
VIN_12/24: BYPASS.1; also elsewhere on the board

## EAGLE design Hardware/Eagle_Files/PiezoDisk-PCB/Pyr0-Piezo_Orion_Adapter_v1.0.0.brd

Parts:
J1: C-GRID-03-70553; 70553-03
U$1, U$2, U$3, U$4: PIEZO-DISK12MM; PIEZO-DISK-12MM

Connections:
GND: J1.1, J1.3, U$1.GND1 (GND), U$1.GND2 (GND), U$1.GND3 (GND), U$1.GND4 (GND), U$2.GND1 (GND), U$2.GND2 (GND), U$2.GND3 (GND), U$2.GND4 (GND), U$3.GND1 (GND), U$3.GND2 (GND), U$3.GND3 (GND), U$3.GND4 (GND), U$4.GND1 (GND), U$4.GND2 (GND), U$4.GND3 (GND), U$4.GND4 (GND)
PIEZO_OUT: J1.2, U$1.PZ+, U$2.PZ+, U$3.PZ+, U$4.PZ+

Board: 2 copper layers, 31.9 x 42.9 mm, 7 parts (0 on the bottom side), 2 nets.

Other parts of the board:
U$5, U$6: LOGO-PYR0BALL-SS-6MM

## EAGLE design Hardware/Eagle_Files/FFC_Direct_Breakout/Pyr0-Piezo_Direct-Extruder-FFC-Breakout_2.0.1.brd

Parts:
5V, 12V: LEDCHIP-LED0805; CHIP-LED0805
C2: 100uf; ALU-C-D5.3MM_LEFT
C3, C4: 100uf; ALU-C-D5.3MM_RIGHT
C5: 10uF; CAPC2012X130
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: DIODE_SCHOTTKY_SINGLE; DO-214AC
E0: C-GRID-04-70553; 70553-04
FAN0, FAN1: C-GRID-02-70553; 70553-02
H1, H2, H3, H4: HOLES_MOUNT-PAD-ROUND3.2; HOLES_3,2-PAD
HE0: KK-156-2
I2C: SEEED-CONNECTOR_DIP-BLACK-FEMALE-HEADER-VERT(4P-2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; HDRVR4W64P254_1X4_1016X254X575B
J1: FFC_MOLEX_0.5MM; FFC-60P_0.5_MOLEX_505110-6091
PWR: KK-156-2
Q2: MMBT2907ALT1-PNP-SOT23-BEC; SOT23-BEC
R1: 240R; SEEED-RESISTOR_R0603
R2: 715R; SEEED-RESISTOR_R0603
R3: 2.05K; SEEED-RESISTOR_R0603
R4: 1K; SEEED-RESISTOR_R0603
R5: 0R; R0805
R6: 1R; R0805
R7: 10R; R0805
SW1: SEEED-SWITCH_DIP-TOGGLE-SWITCH-2CH-(2X3P-2.54)DPD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; SEEED-SWITCH_SW6-2.54-9.0X3.5X3.2+2.0MM
TH1: C-GRID-02-70553; 70553-02
U1: LM317DCY; SOT230P700X180-4N
U2: L78L05ACU; SOT89
UART: JST-2.54MM_5P-2.54JST_2.54MM_5P_F; HDRVR5W64P254_1X5_1270X254X575B
X_MIN: C-GRID-02-70553; 70553-02
X_MOT: C-GRID-04-70553; 70553-04
Z_MIN: C-GRID-02-70553; 70553-02

Connections:
5V_ADJ: R2.2, SW1.CH1A
5V_LED: 5V.A, SW1.CH2A
12V_ADJ: R3.2, SW1.CH1B
12V_LED: 12V.A, SW1.CH2B
+5V: C3.+, Q2.C, R5.2, U2.1 (OUT)
AGND: 5V.C, 12V.C, C2.-, C3.-, C4.-, C5.1, D1.A, D3.A, D5.A, D7.A, D9.A, D11.A, D13.A, D15.A, H1.B3,2, H2.B3,2, H3.B3,2, H4.B3,2, I2C.2, J1.9 (11), J1.10 (12), J1.29 (31), J1.30 (32), J1.47 (53), J1.48 (54), J1.S$1 (S), J1.S$2 (S), PWR.1, R2.1, R3.1, U2.2 (GND), U2.PAD, UART.2, X_MIN.1, Z_MIN.1
BYP_GATE: Q2.B, R7.2
E0_1A: D13.C, D14.A, E0.2, J1.3 (5), J1.4 (6)
E0_1B: D15.C, D16.A, E0.1, J1.1 (3), J1.2 (4)
E0_2A: D11.C, D12.A, E0.3, J1.5 (7), J1.6 (8)
E0_2B: D9.C, D10.A, E0.4, J1.7 (9), J1.8 (10)
FAN0_GATE: FAN0.1, J1.31 (37)
FAN1_GATE: FAN1.1, J1.32 (38)
HE0-: HE0.1, J1.39 (45), J1.40 (46), J1.41 (47), J1.42 (48), J1.43 (49), J1.44 (50), J1.45 (51), J1.46 (52)
LED_R: R4.2, SW1.COM2
LM317_VADJ: R1.1, SW1.COM1, U1.1 (ADJUST)
PT_100_OUT: J1.28 (30)
RST: J1.23 (25), UART.5
RXD: J1.22 (24), UART.4
SCL: I2C.4, J1.20 (22)
SDA: I2C.3, J1.19 (21)
TH0+: J1.33 (39), TH1.1
TH0-: J1.34 (40), TH1.2
TXD: J1.21 (23), UART.3
VCC: C2.+, D2.C, D4.C, D6.C, D8.C, D10.C, D12.C, D14.C, D16.C, FAN0.2, FAN1.2, HE0.2, J1.49 (55), J1.50 (56), J1.51 (57), J1.52 (58), J1.53 (59), J1.54 (60), J1.55 (61), J1.56 (62), J1.57 (63), J1.58 (64), J1.59 (65), J1.60 (66), PWR.2, Q2.E, R6.1, U1.3 (INPUT)
VCC_REG: I2C.1, J1.24 (26), J1.25 (27), R5.1, UART.1
VREG_IN: R6.2, R7.1, U2.3 (IN)
V_INT: C4.+, C5.2, J1.35 (41), J1.36 (42), J1.37 (43), J1.38 (44), R1.2, R4.1, U1.4 (OUTPUT)
X_1A: D5.C, D6.A, J1.13 (15), J1.14 (16), X_MOT.2
X_1B: D7.C, D8.A, J1.11 (13), J1.12 (14), X_MOT.1
X_2A: D3.C, D4.A, J1.15 (17), J1.16 (18), X_MOT.3
X_2B: D1.C, D2.A, J1.17 (19), J1.18 (20), X_MOT.4
X_MIN_TRIG: J1.27 (29), X_MIN.2
Z_MIN_TRIG: J1.26 (28), Z_MIN.2

Notes on the sheet:
5V / 12V Switchable Fan Supply
5V Ripple Rejected AVR/Piezo Supply

Board: 2 copper layers, 64.8 x 63.9 mm, 50 parts (16 on the bottom side), 33 nets.

Other parts of the board:
U$1: LOGO-PYR0BALL

## EAGLE design Hardware/Eagle_Files/Pyr0-Piezo_AVR_Programmer/Pyr0-Piezo-AVR_Board_programmer_0.1.brd

Parts:
+5V: TP; TP13SQ-HOLE
C1, C2: 0.1uF; CAPC1005X50
D1: SP0503BAHTG; SOT143
D2: TVS_DIODE_CM1293A; SC-74-6
GND: TP; TP13SQ-HOLE
H1, H2, H3: HOLES_MOUNT-PAD-ROUND2.8; HOLES_2,8-PAD
ICSP0, ICSP2: ICSP_HEADERICSP-2MM; HDRV6W50P200_3X2_400X600X550B
ICSP1: ICSP_HEADERICSP_2.54MM_RIGHT; HDRRA6W64P254_2X3_762X254X508B
J1: 10118192-0001LF; AMPHENOL_10118192-0001LF
PWR: SEEED-LED_SMD-LED-CLEAR-BLUE(0603)LED_0603; SEEED-LED_LED-0603
R1: 22K; R0402
R2: 47K; R0402
R3, R8: SMD-RES-0R-5%-1/16W(0402); R0402
R4: 10K; R0402
RESET: SEEED-SWITCH_SMD-BUTTON(2P-3.0X2.5X1.2+0.4MM)SW2-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; SEEED-SWITCH_SW2-2.6-3.0X2.5X1.2+0.4MM
RST.: TP; TP13SQ-HOLE
RX: SEEED-LED_SMD-LED-CLEAR-BLUE(0603)LED_0603; SEEED-LED_LED-0603
RXD: TP; TP13SQ-HOLE
TTL: JST-2.54MM_5P-2.54JST_2.54MM_5P_F; HDRVR5W64P254_1X5_1270X254X575B
TX: SEEED-LED_SMD-LED-CLEAR-BLUE(0603)LED_0603; SEEED-LED_LED-0603
TXD: TP; TP13SQ-HOLE
U1: CP2102N-A01-GQFN28; QFN50P500X500X80-29N

Connections:
5V_DC: +5V.TP, C2.2, D1.2, D2.5 (V+), J1.1 (VUSB), R1.2, R3.1, R8.1, TTL.1, U1.7 (VREGIN)
D+: D1.4, D2.3 (CH$1), J1.3 (D+), U1.4 (D+)
D-: D1.3, D2.1 (CH$1), J1.2 (D-), U1.5 (D-)
GND: C2.1, D1.1, D2.2 (V-), GND.TP, H1.B2,8, H2.B2,8, H3.B2,8, ICSP0.2 (GND), ICSP1.3 (GND), ICSP2.2 (GND), J1.5 (GND), J1.SH1 (SHIELD), J1.SH2 (SHIELD), J1.SH3 (SHIELD), J1.SH4 (SHIELD), J1.SH5 (SHIELD), J1.SH6 (SHIELD), PWR.-, R2.1, RESET.1, TTL.2, U1.3 (GND), U1.29 (GND)
LED_VCC: R3.2, RX.+, TX.+
unnamed: PWR.+, R8.2
PGM_RST: C1.2, R4.2, U1.28 (DTR)
RST: C1.1, ICSP0.1 (RST), ICSP1.4 (RST), ICSP2.1 (RST), RESET.2, RST..TP
RXD: RXD.TP, TTL.4, U1.26 (TXD)
RXT: RX.-, U1.19 (GPIO.0/TXT)
SPI_MISO: ICSP0.5 (MISO), ICSP1.6 (MISO), ICSP2.5 (MISO)
SPI_MOSI: ICSP0.3 (MOSI), ICSP1.2 (MOSI), ICSP2.3 (MOSI)
SPI_SCK: ICSP0.4 (SCK), ICSP1.5 (SCK), ICSP2.4 (SCK)
TXD: TTL.3, TXD.TP, U1.25 (RXD)
TXT: TX.-, U1.18 (GPIO.1/RXT)
VBUS: ICSP0.6 (VCC), ICSP1.1 (VCC), ICSP2.6 (VCC), R1.1, R2.2, R4.1, TTL.5, U1.8 (VBUS)
VDD: U1.6 (VDD)

Board: 2 copper layers, 39.6 x 46.5 mm, 29 parts (11 on the bottom side), 16 nets.

Other parts of the board:
U$1, U$2: LOGO-PYR0BALL-SS-20MM

## EAGLE design Hardware/Eagle_Files/FFC_X-Car_Direct_Breakout/Pyr0-Piezo-FFC-Direct-Creality-X-Board.2.1.2.brd

Parts:
D1: SEEED-LED_SMD-LED-CLEAR-BLUE(0603)LED_0603; SEEED-LED_LED-0603
H1, H2, H3, H4: HOLES_MOUNT-PAD-ROUND3.2; HOLES_3,2-PAD
J3, J4: FFC-15P-1MM
R1: 2K; R0805
R2: 4K7; R0805
X1, X2: FFC-40P-0.5SH; FH12-40S-0.5SH
X-MOT: C-GRID-04-70553; 70553-04
X_MIN: LIMIT_SWITCH; LIMIT_SWITCH_BRIDGE

Connections:
AGND: H1.B3,2, H2.B3,2, H3.B3,2, H4.B3,2, J3.P$7, J3.P$12, J3.P$15, J3.P$16 (TP), J3.P$17 (TP), J4.P$1, J4.P$4, J4.P$9, J4.P$16 (TP), J4.P$17 (TP), X1.9 (1), X1.10 (1), X1.34 (1), X1.35 (1), X1.36 (1), X1.37 (1), X1.38 (1), X1.39 (1), X1.40 (1), X1.TAB0 (S), X1.TAB1 (S), X2.1, X2.2 (1), X2.3 (1), X2.4 (1), X2.5 (1), X2.6 (1), X2.7 (1), X2.TAB0 (S), X2.TAB1 (S), X_MIN.NO
E0_1A: X1.3 (1), X1.4 (1), X2.37 (1), X2.38 (1)
E0_1B: X1.1, X1.2 (1), X2.39 (1), X2.40 (1)
E0_2A: X1.5 (1), X1.6 (1), X2.35 (1), X2.36 (1)
E0_2B: X1.7 (1), X1.8 (1), X2.33 (1), X2.34 (1)
FAN0_GATE: X1.30 (1), X2.11 (1)
FAN1_GATE: X1.31 (1), X2.10 (1)
HE0-: J3.P$8, J3.P$9, J3.P$10, J3.P$11, J4.P$5, J4.P$6, J4.P$7, J4.P$8
PT100_OUT: X1.28 (1), X1.29 (1), X2.12 (1), X2.13 (1)
RST: X1.23 (1), X2.18 (1)
RXD: X1.22 (1), X2.19 (1)
SCL: X1.20 (1), X2.21 (1)
SDA: X1.19 (1), X2.22 (1)
TH0+: X1.32 (1), X2.9 (1)
TH0-: X1.33 (1), X2.8 (1)
TXD: X1.21 (1), X2.20 (1)
VCC: J3.P$1, J3.P$2, J3.P$3, J3.P$4, J3.P$5, J3.P$6, J4.P$10, J4.P$11, J4.P$12, J4.P$13, J4.P$14, J4.P$15
VCC_REG: R1.2, X1.24 (1), X1.25 (1), X2.16 (1), X2.17 (1)
V_INT: J3.P$13, J3.P$14, J4.P$2, J4.P$3
X_1A: X1.13 (1), X1.14 (1), X-MOT.2
X_1B: X1.11 (1), X1.12 (1), X-MOT.1
X_2A: X1.15 (1), X1.16 (1), X-MOT.3
X_2B: X1.17 (1), X1.18 (1), X-MOT.4
X_MIN_LED: D1.+, R1.1
X_MIN_TRIG: D1.-, R2.2, X1.27 (1), X2.14 (1)
X_PULLDOWN: R2.1, X_MIN.COM
Z_MIN_TRIG: X1.26 (1), X2.15 (1)

Board: 2 copper layers, 39.8 x 43.8 mm, 14 parts (4 on the bottom side), 27 nets.

Other parts of the board:
U$1: LOGO-PYR0BALL
