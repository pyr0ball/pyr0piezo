# Repository pyr0ball/pyr0piezo (continued)

## EAGLE design Hardware/Eagle_Files/FFC_Direct_Extruder/Pyr0-Piezo_Direct_Extruder_Board1.1.0.brd

Parts:
5V: TPTP13SQ; TP13SQ
+5V: TPTP13SQ; TP13SQ
ADJ+: TPTP10R; TP10R
ADJ-: TPTP10R; TP10R
A_OUT: TPTP10R; TP10R
C1, C2, C4: 0.1uF; CAPC1005X50
C3: 1uF; CAPC1609X80
D1: DIODE_ZENER_PLZ5V1C; DO-219AC
D2, D3, D4, D5: SEEED-LED_SMD-LED-CLEAR-BLUE(0603)LED_0603; SEEED-LED_LED-0603
D8: BAV199; SOT23
E0: C-GRID-04-70553; 70553-04
ERR: SEEED-LED_SMD-LED-CLEAR-BLUE(0603)LED_0603; SEEED-LED_LED-0603
F1: 0R; SEEED-RESISTOR_R0603
FAN0, FAN1: CON-MOLEX-2P-1.27MM048; 53048-02
GND: TPTP13SQ; TP13SQ
H1, H2, H3: HOLES_MOUNT-PAD-ROUND2.8; HOLES_2,8-PAD
HE0: JST-2.54-2X2JST-DUPONT-2.54-2X2; HDRRAR4W64P254_2X2_556X736X556B
INT: TPTP06R; TP06R
J1: SFW24R-1STE1LF; CON24_1X24_DRB_SFW
MISO: TPTP13SQ; TP13SQ
MOSI: TPTP13SQ; TP13SQ
PWR: SEEED-LED_SMD-LED-CLEAR-BLUE(0603)LED_0603; SEEED-LED_LED-0603
PZ1: CON-MOLEX-2P-1.27MM048; 53048-02
R1, R19: 1M; R0402
R2, R4, R10: 10K; R0402
R3, R6, R8: 1K; R0402
R5, R12: 330R; R0402
R7, R11: 220R; R0402
R9: 470R; R0402
R13: 100R; R0402
R15: 680R; R0402
R17: 3.3K; R0402
RST, RST.: TPTP13SQ; TP13SQ
RXD: TPTP13SQ; TP13SQ
SCK: TPTP13SQ; TP13SQ
SCL: TPTP13SQ; TP13SQ
SDA: TPTP13SQ; TP13SQ
SS: TPTP06R; TP06R
TH0: CON-MOLEX-2P-1.27MM048; 53048-02
TRG: SEEED-LED_SMD-LED-CLEAR-BLUE(0603)LED_0603; SEEED-LED_LED-0603
TXD: TPTP13SQ; TP13SQ
U1: ATMEGA48/88/168/328PA28M1-M; 28M1-M
U2: LM2902QT; QFN16
⏚: TPTP13SQ; TP13SQ

Connections:
+5V: +5V.TP, C1.1, C4.2, D8.2 (C), F1.2, R3.1, R8.1, R10.2, R15.1, U1.3 (VCC), U1.16 (AVCC), U2.2 (V+)
COMP-: ADJ+.TP, R1.2, R2.2, U2.7 (OUT), U2.16 (-IN)
E0_1A: E0.2, J1.3 (33), J1.4 (44)
E0_1B: E0.1, J1.1 (11), J1.2 (22)
E0_2A: E0.3, J1.5 (55), J1.6 (66)
E0_2B: E0.4, J1.7 (77), J1.8 (88)
ERR_LED: ERR.+, U1.1 ((PCINT19/OC2B/INT1)_PD3)
FAN0_GATE: D5.-, FAN0.1, J1.17 (1717)
FAN1_GATE: D4.-, FAN1.1, J1.15 (1515)
GAIN_FB: R2.1, R17.2, U2.8 (-IN)
GND: C1.2, C2.1, C3.2, C4.1, D1.P$1 (A), D2.-, D8.1 (A), ERR.-, GND.TP, H1.B2,8, H2.B2,8, H3.B2,8, J1.12 (1212), J1.14 (1414), J1.16 (1616), J1.18 (1818), J1.25 (2525), J1.26 (2626), PWR.-, PZ1.1, R4.1, R9.1, R17.1, R19.1, TRG.-, U1.4 (GND_2), U1.18 (GND), U1.29, U2.11 (V-), ⏚.TP
HE0-: D3.-, HE0.3, HE0.4, J1.21 (2121), J1.22 (2222)
LED_VCC: D3.+, D4.+, D5.+, R3.2
PWR_LED: PWR.+, R8.2
PZ+: D8.3 (AC), PZ1.2, R19.2, U2.9 (+IN)
PZ_AMP_OUT: A_OUT.TP, R13.1, U2.15 (OUT)
RST: RST.TP, RST..TP, U1.25 (PC6_(RESET/PCINT14))
SCL: SCL.TP, U1.24 (PC5_(ADC5/SCL/PCINT13))
SDA: SDA.TP, U1.23 (PC4_(ADC4/SDA/PCINT12))
SPI_MISO: MISO.TP, U1.14 ((PCINT4/MISO)_PB4)
SPI_MOSI: MOSI.TP, U1.13 ((PCINT3/OC2A/MOSI)_PB3)
SPI_SCK: SCK.TP, U1.15 (PB5_(SCK/PCINT5))
SPI_SS: SS.TP, U1.12 ((PCINT2/SS/OC1B)_PB2)
TH0+: J1.20 (2020), TH0.1
TH0-: J1.19 (1919), TH0.2
TRG_LED: D2.+, R6.2, TRG.+
TTL_RXD: RXD.TP, U1.26 (PD0_(RXD/PCINT16))
TTL_TXD: TXD.TP, U1.27 (PD1_(TXD/PCINT17))
VADJ_R0: R7.1, R11.2, U1.5 ((PCINT6/XTAL1/TOSC1)_PB6)
VADJ_R1: R11.1, R12.2, U1.6 ((PCINT7/XTAL2/TOSC2)_PB7)
VADJ_R2: R5.2, R12.1, U1.7 ((PCINT21/OC0B/T1)_PD5)
VADJ_R3: R5.1, R9.2, U1.8 ((PCINT22/OC0A/AIN0)_PD6)
VADJ_SENSE: ADJ-.TP, R7.2, R15.2, U1.20 (PC1_(ADC1/PCINT9)), U2.1 (+IN)
VCC: HE0.1, HE0.2, J1.23 (2323), J1.24 (2424)
VCC_REG: 5V.TP, C2.2, D1.P$2 (C), F1.1, J1.9 (99)
VREF_IN: R4.2, R10.1, U2.4 (+IN)
V_FOLLOW: R1.1, U1.19 (PC0_(ADC0/PCINT8)), U2.5 (-IN), U2.6 (OUT)
V_INT: C3.1, FAN0.2, FAN1.2, J1.10 (1010), J1.11 (1111)
Z_MIN_TRIG: J1.13 (1313), R6.1, U1.11 ((PCINT1/OC1A)_PB1)
Z_TRG: INT.TP, R13.2, U1.28 (PD2_(INT0/PCINT18))

Notes on the sheet:
ATMega48
Power
LED's
Holes
Piezo Amp Circuit
Test Points
Connectors
VRef Buffer
Auto Adjust Ladder
Comparator
Piezo In
Amplifier - 3X Gain
2.50V +/- 20mV
- +

Board: 2 copper layers, 38.1 x 46.5 mm, 61 parts (21 on the bottom side), 40 nets.

Other parts of the board:
U$1: LOGO-PYR0BALL-SS-20MM

## Code that names these connections

File firmware/AVR-Source/Pyr0_Piezo_Sensor_v2.x.x/src/pP_pins.h:

/* pyr0-piezo pins configuration file

Default pins (based on Rev.2.x.xPCB layout)

 * PD2 INT0 (Piezo In 'D2')
 * D7 PCINT23 (Trigger OUT 'D7')
 * PC0 ADC0 (Voltage Reference Check 'A0')
 * PC1 ADC1 (Sensitivity Adjustment Check 'A1')
 * PD4 PCINT20 (Error feedback LED 'D4')
 * PB6 PCINT6 (Voltage Adjustment Resistor 0 'D20')
 * PB7 PCINT7 (Voltage Adjustment Resistor 1 'D21')
 * PD5 T1 (Voltage Adjustment Resistor 2 'D5')
 * PD6 PCINT22 (Voltage Adjustment Resistor 3 'D6')
 * PB1 OC1A (Comparator VRef PWM Out 'D9')
 * PD3 OC2B (Voltage Follower VRef PWM Out 'D3')
*/

#ifdef __AVR_ATmega328PB__ // Pin assignments for 328PB variant

// Analog Pin Assignments
#define V_FOLLOW_PIN A0    // Sense pin to check Voltage Follower stage
#define VCOMP_SENSE_PIN A1 // Sense pin to check comparator stage voltage

// Digital Pin Assignments
#define TRG_OUT 7 // LED and Z-Min trigger output connected to digital pin 7
//#define TRG_OUT 13      // For testing on Atmega328/2560, Output is moved to onboard LED pin
#define Z_TRG 2      // the piezo is connected to INT0 / digital pin 2
#define ERR_LED 4    // LED will blink if optimal voltage range cannot be achieved
#define GADJ_R0 20   // Auto-adjust ladder pin assignments
#define GADJ_R1 21   // "
#define GADJ_R2 5    // "
#define GADJ_R3 6    // "
#define V_FOL_PWM 3  // PWM analog output pin for voltage follower adjustment
#define VCOMP_PWM 9  // PWM analog output pin for comparator adjustment
#define PZDET_PIN 16 // Digital input pin for detecting piezo connection
#define SIGVOL_PIN 8  // VCC variable regulator switch pin

#endif //__AVR_ATmega328PB__

#ifdef __AVR_ATmega328P__ // Pin assignments for 328P variant

// Analog Pin Assignments
#define V_FOLLOW_PIN A0    // PC0 Sense pin to check Voltage Follower stage
#define VCOMP_SENSE_PIN A1 // PC1 Sense pin to check comparator stage voltage

// Digital Pin Assignments
#define TRG_OUT 7 // LED and Z-Min trigger output connected to digital pin 7
//#define TRG_OUT 13      // For testing on Atmega328/2560, Output is moved to onboard LED pin
#define Z_TRG 2      // the piezo is connected to INT0 / digital pin 2
#define ERR_LED 4    // LED will blink if optimal voltage range cannot be achieved
#define GADJ_R0 20   // PB6 Auto-adjust ladder pin assignments
#define GADJ_R1 21   // PB7 "
#define GADJ_R2 5    // PD5 "
#define GADJ_R3 6    // PD6 "
#define V_FOL_PWM 3  // PD3 PWM analog output pin for voltage follower adjustment
#define VCOMP_PWM 9  // PB1 PWM analog output pin for comparator adjustment
#define PZDET_PIN 16 // PC2 Digital input pin for detecting piezo connection
#define SIGVOL_PIN 8  // PB0 VCC variable regulator switch pin

#endif //__AVR_ATmega328P__

File ATmega48_Piezo_Sensor/ATmega48_Piezo_Sensor.ino:

/*
  Piezoelectric Z-Axis sensor using AtMega48/88

  This sketch reads a piezo element to detect a touch of the printer's nozzle to the bed.
  The sense pin is tied to an interrupt, which is pulled high by internal pullup resistor.
  When the piezo touches the bed, the amplification circuit will draw the interrupt pin low
  and the atmega will output a pulse based on the programmed trigger duration
  
 * PD2 INT0 (Piezo In 'D2')
 * PB1 PCINT1 (Trigger OUT 'D9')
 * PC0 ADC0 (Voltage Reference Check 'A0')
 * PC1 ADC1 (Sensitivity Adjustment Check 'A1')
 * PD3 INT1 (Error feedback LED 'D3')
 * PB6 PCINT6 (Voltage Adjustment Resistor 0 'D20')
 * PB7 PCINT7 (Voltage Adjustment Resistor 1 'D21')
 * PD5 T1 (Voltage Adjustment Resistor 2 'D5')
 * PD6 PCINT22 (Voltage Adjustment Resistor 3 'D6')

  created 1/8/2019
  by Alan "pyr0ball" Weinstock

  This code is in the public domain.
  Based off examples from:
  http://www.arduino.cc/en/Tutorial/Knock
  http://www.circuitbasics.com/arduino-ohm-meter/
*/

// Set variables for working parameters
const int TRG_OUT = 9;         // LED and Z-Min trigger output connected to digital pin 10
//const int TRG_OUT = 13;      // For testing on Atmega328/2560, Output is moved to onboard LED pin
//#define Z_TRG 0                // the piezo is connected to INT0 / digital pin 2
const byte Z_TRG = 2;
int ERR_LED = 3;               // LED will blink if optimal voltage range cannot be achieved
int InitCount = 6;             // Number of times to blink the LED on start
int V_FOLLOW_PIN = A0;             // Sense pin to check first amp stage voltage output
int VADJ_SENSE_PIN = A1;           // Sense pin to check comparator stage voltage
int TRG_DUR = 120;             // duration of the Z-axis pulse sent, in ms
int Vin = 5;                   // input reference voltage
float senseHighThrs = 2.47;    // Upper threshold voltage of amp circuit before adjustment
float senseLowThrs = 1.90;     // Lower threshold voltage of amp circuit before adjustment
const int VADJ_R0 = 20;        // Auto-adjust ladder pin assignments
const int VADJ_R1 = 21;
const int VADJ_R2 = 5;
const int VADJ_R3 = 6;

// these variables will change on their own. Do not edit them
volatile int sensorHReading = 0;      // variable to store the value read from the sensor pin
volatile int ADJ_STATE = 0;             // Variable for voltage adjustment ladder
volatile int ERR_STATE = 0;
int folRead = 0;
float VRef = 0.00;                 // variable to store the value read from the reference voltage
int vadjRead = 0;
float VAdj = 0.00;                    // variable to store the value read from the second amp stage
int BlinkState = LOW;
int BlinkCount = InitCount * 2; // Multiply Blink count by 2 to handle toggle state
float diffAdjL = VAdj - senseLowThrs;
float diffAdjH = senseHighThrs - VAdj;

void setup() {
  pinMode(TRG_OUT, OUTPUT); // declare the Trigger as as OUTPUT
  pinMode(ERR_LED, OUTPUT);
  pinMode(Z_TRG, INPUT_PULLUP); // declare z-sense input with pullup
  pinMode(V_FOLLOW_PIN, INPUT);
  pinMode(VADJ_SENSE_PIN, INPUT);
  pinMode(VADJ_R0, INPUT); // declare input to break pull to ground
  pinMode(VADJ_R1, INPUT); // declare input to break pull to ground
  pinMode(VADJ_R2, INPUT); // declare input to break pull to ground
  pinMode(VADJ_R3, INPUT); // declare input to break pull to ground
  Serial.begin(9600);

  // Uncomment the following lines to use PCInt pins instead of hardware interrupt
  //#include <PinChangeInterrupt.h>
  //attachPCINT(digitalPinToPCINT(Z_TRG), pulse, FALLING);

  // Uncomment the followoing line to use hardware interrupt pin
  attachInterrupt(digitalPinToInterrupt(Z_TRG), pulse, FALLING);

  Serial.println("Initializing Piezo Sensor...");
  
}

void pulse() {
  digitalWrite(TRG_OUT, HIGH);
  sensorHReading = 1;
}

void adjustState() {
  
  if (diffAdjL > 0.0) {
    ADJ_STATE++;
  }
  
  if (diffAdjH > 0.0) {
    ADJ_STATE--;
  }
  Serial.print("adjustState:");
  Serial.println(ADJ_STATE);
  Serial.println("--------------------");
}

void adjustVoltage() {

  if  (ADJ_STATE < 0) {
    ERR_STATE = 1;
  }
  if (ADJ_STATE == 0) {
    pinMode(VADJ_R3, INPUT);
    pinMode(VADJ_R2, INPUT);
    pinMode(VADJ_R1, INPUT);
    pinMode(VADJ_R0, INPUT);
    ERR_STATE = 0;
  }
  if (ADJ_STATE > 0) {
    pinMode(VADJ_R3, OUTPUT);
    digitalWrite(VADJ_R3, LOW);
    pinMode(VADJ_R2, INPUT);
    pinMode(VADJ_R1, INPUT);
    pinMode(VADJ_R0, INPUT);
    ERR_STATE = 0;
  }
  if (ADJ_STATE > 1) {
    pinMode(VADJ_R2, OUTPUT);
    digitalWrite(VADJ_R2, LOW);
    pinMode(VADJ_R1, INPUT);
    pinMode(VADJ_R0, INPUT);
    ERR_STATE = 0;
  }
  if (ADJ_STATE > 2) {
    pinMode(VADJ_R1, OUTPUT);
    digitalWrite(VADJ_R1, LOW);
    pinMode(VADJ_R0, INPUT);
    ERR_STATE = 0;
  }
  if (ADJ_STATE > 3) {
    pinMode(VADJ_R0, OUTPUT);
    digitalWrite(VADJ_R0, LOW);
    ERR_STATE = 0;
  }
  if  (ADJ_STATE > 4) {
    ERR_STATE = 1;
  }
}

void checkError () {
  if (ERR_STATE == 1) {
    digitalWrite(ERR_LED, BlinkState);
    BlinkState = !BlinkState;
  }
  if (ERR_STATE == 0) {
    BlinkState = LOW;
    digitalWrite(ERR_LED, BlinkState);
  }
}

void loop() {
  
  // Blink LED's on init
  if (BlinkCount > 0) {
    BlinkState = !BlinkState;
    digitalWrite(ERR_LED, BlinkState);
    digitalWrite(TRG_OUT, BlinkState);
    delay(150);
    --BlinkCount;
  }

  // Check voltage of first and second stages and compare against thresholds
  folRead = analogRead(V_FOLLOW_PIN);
  VRef = (folRead * 5.0) / 1024.0;
  vadjRead = analogRead(VADJ_SENSE_PIN);
  VAdj = (vadjRead * 5.0) / 1024.0;
  diffAdjL = VAdj - senseLowThrs;
  diffAdjH = senseHighThrs - VAdj;
  
  // Voltage state adjustment
  adjustState();

  // Voltage divider adjustment
  adjustVoltage();
  
  // Check for error state
  checkError();

  // Checks state of the interrupt trigger, prints status, then sets output pin low
    Serial.print("PZ Status:");
    Serial.println(sensorHReading);
    Serial.print("Voltage Reference:");
    Serial.println(VRef);
    Serial.print("Amp Sense:");
    Serial.println(VAdj);
    Serial.print("Adjustment State:");
    Serial.println(ADJ_STATE);
    Serial.print("Delay:");
    Serial.println(TRG_DUR);
    Serial.print("Low Diff:");
    Serial.println(diffAdjL);
    Serial.print("High Diff:");
    Serial.println(diffAdjH);
    Serial.print("Error State:");
    Serial.println(ERR_STATE);
    Serial.println("------------------");
    delay(TRG_DUR);
    digitalWrite(TRG_OUT, LOW);
    sensorHReading = 0;
}

## Commit log (part)

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2019-02-25 Added schematic for wiring up UART for programming
    Addition to https://github.com/pyr0ball/pyr0piezo/issues/14
2019-02-25 added ignore for openoffice text temp files
2019-02-26 renamed firmware update docs
2019-02-27 fixed some spacing and labelling
2019-02-27 aligned caps for easier soldering
2019-03-09 Updated library and components
2019-03-09 Swapped Atmega for ATSAMD21E family MCU
    Started work on https://github.com/pyr0ball/pyr0piezo/issues/21
    Started work on https://github.com/pyr0ball/pyr0piezo/issues/22
    Started pin assignments and board mapping for ARM MCU
    Added i2c pins to input header
2019-03-13 repositioned filter cap for easier soldering
2019-03-14 Replaced serial parser, verified parameters update
    Progress on https://github.com/pyr0ball/pyr0piezo/issues/2
    See notes on wiki for serial input format
2019-03-16 fixed syntax preventing compilation
2019-03-18 Added hookup guides for common MKS boards
    progress on https://github.com/pyr0ball/pyr0piezo/issues/14
2019-03-18 Begin sync of Rev.2.0.1 changes
2019-03-23 sync all boards for Rev.2.0.1 before gerberization
    - added test pads for debugging amp circuit
2019-03-27 Brought library additions to older rev boards
2019-04-08 Beta production board sync
2019-04-12 Updated link to license
2019-04-22 fixed unary operators for adjustment logic
    - Switched unary operators to correct syntax (+= vs =+) Should fix oscillation noted in https://github.com/pyr0ball/pyr0piezo/issues/24
    - Added software hysteresis to the adjustment function. Referenced in https://github.com/pyr0ball/pyr0piezo/issues/24
    - Fixed notes to show the correct gain factors
2019-04-22 Converting to defines and else ifs
    Defines save flash and progmem and elseifs increase execution speed on code repeated on every loop.
    Side note, something funky happened with the spacing. Fixed it, but it's slightly different than what it was before.
2019-04-22 Added function to alert the user when calibrating
2019-06-11 for v2.x this fixes https://github.com/pyr0ball/pyr0piezo/issues/28
2019-06-11 changed adc calculations to use Vin reference
2019-06-27 Fixed "Flappy DAC" bug in rev.2.x.x firmware
    - Fixed https://github.com/pyr0ball/pyr0piezo/issues/26
    - Changed adjustment logic to be calculated based on Vcc rather than ADC reference, which was causing issues in the mathematical functions, resulting in negative number outputs
    - Migrated to internal vRef, fixed https://github.com/pyr0ball/pyr0piezo/issues/23
    - Eliminated floats, fixing https://github.com/pyr0ball/pyr0piezo/issues/31
    - This required addition of long, however
    - Fixed https://github.com/pyr0ball/pyr0piezo/issues/20
2019-07-01 Added mkdocs for readthedocs integration
2019-07-02 added document structure, site output to gitignore
2019-07-06 Switched to task scheduler library for faster interrupt processing
2019-07-06 Changed compiler structure for including I2C
2019-07-19 Migrated configs to separate header file, made adjustment to definition
2019-07-25 Migrated from single 60pin FFC to combined 15+40p
    - 60pin cables are nearly impossible to source in longer sizes
    - both 15p-1mm and 40p-0.5mm are readily available as one is used for
    Raspberry Pi cameras, and the other is used for eDP and LVDS
    - This method also allows for more ground return paths and better
    voltage distribution
2019-07-25 renamed wiki folder to assets
2019-07-25 Added issue template for requesting a new mount
2019-07-25 added a few other kinematics to the install structure
2019-07-25 fixed menu structure for mkdocs
2019-07-25 fixed issue with markdown nested bullets on install page
2019-07-25 renamed ultimaker to "quadrap" to better reflect nomenclature
2019-07-25 Started on documentation for the Monoprice Delta Mini
2019-07-25 Added instructions for monoprice-delta-mini
2019-07-26 renamed folders
2019-07-26 Added Printer firmware configuration for Marlin
2019-07-26 added favicon
2019-07-26 added png favicon
2019-07-26 updated readme and about
2019-07-26 fixed override syntax
2019-07-26 fixing logo
2019-07-26 resize header logo
2019-07-26 removed unneeded link
2019-07-26 Update issue templates
2019-08-11 added links for drawings
2019-08-11 renamed drawing and schematics folders
2019-08-13 fixed embedded pdf layout size
2019-08-13 fixed syntax
2019-08-13 moved wiring diagrams section to installation
2019-08-15 Fixed syntax issue with changelog script
2019-08-15 fixed some syntax with regex for the changelog
2019-08-15 added additional separator between sections added by changelog script #bugfix
2019-08-29 commented out main loop trigger reset #bugfix
    After switching to the new scheduler, the main loop was resetting the
    trigger too quickly. Migrating reset to the pulse trigger function
    instead
2019-08-29 Added gain factor to serial debug output #featureadd
2019-08-29 added regex filter to changelog.sh
    removes the category tags from public output
2019-08-29 fixed footprint for RGB LED (default polarity was backwards) #bugfix
2019-08-30 new version EasyPiezi-v2.1.2 - adds extra test points #featureadd
2019-08-31 fixed permissions on scripts
2019-09-24 Fixed serial input updating the wrong variable #bugfix
2019-09-25 added explaination on how to fine-tune VccMeter. #changelog
    Reshuffled some of the other parts of the readVcc function
    moved MUX setup to the void setup function
2019-09-25 updated changelog to latest tag
2019-09-25 synced nomenclature for vfollower variables #bugfix
2019-09-25 complete overhaul of serial input and debug output #featureadd
    Input is now parsed without the "<,>" characters
2019-09-25 actually added some of the changes intended for previous commit
2019-09-25 migrated vscode comfig files
2019-09-25 Cleanup remaining merge files #changelog
2019-09-25 Added input parameter for vref constant #featureadd
    Added an option to change the vref constant over serial
2019-09-25 added changelog for v2.1.4 (Loredan's Additions)
2019-09-25 fixed variable type for vm-constant serial input #bugfix
2019-09-26 Fix for serial terminal line break symbol #bugfix
2019-09-26 Exported compiled firmware for m88p - v2.1.4 #featureadd
2019-09-30 Removed old debug output define and sensor trigger debug output, modified VComp and VFol output to mV instead of 10-bit number #changelog
2019-09-30 Fixed internal oscillator frequency configuration on ATmega88P, added configuration for ATmega328PB #changelog
2019-10-03 Code formatting unified
2019-10-05 analogWrite is replaced with native phase correct PWM, 4kHz 10-bit on comparator and 16kHz 8-bit on voltage follower #changelog
2019-10-09 Firmware shipped with Beta2 (v2.1.0) #changelog
2019-10-11 Added some images for v2.1.2 boards #docs
2019-10-11 removed redundant changelog file #docs
2019-10-12 Added beginning of doc explaining circuit settings #docs
    - begin work on https://github.com/pyr0ball/pyr0piezo/issues/45
2019-10-15 typo fix in docs #docs
2019-10-16 fixed polarity for trigger LED on DIY board #bugfix
2019-10-24 Added page for PT100 RTD sensor #docs
    - Starts work on https://github.com/pyr0ball/pyr0piezo/issues/44
2019-10-24 attempting to fix the discord widget in README #docs
2019-10-27 fixed definition preventing serial response in #49 #bugfix
2019-10-29 Exported Eagle parts library into project #featureadd
    - stopgap for https://github.com/pyr0ball/pyr0piezo/issues/52
2019-10-29 Fixed config reset #54 #bugfix
2019-10-29 Added serial feedback for trigger function #featureadd
2019-10-30 This code change reduces the amount of EEPROM writes that could potentially occur within a short period of time, thus making the EEPROM last longer.
2019-10-31 Documentation update for v2.1.5 #docs
2019-11-05 Fixed width of thermals on singledisk adapter #bugfix
2019-11-13 slight edit to platformio.ini, added dependencies
2019-11-26 ignore
2019-12-19 fixing serial input not taking effect immediately #bugfix
    Not a complete fix, still needs work
2019-12-28 Added piezo disk connection detection #featureadd
    - First implementation for #46
2019-12-31 fixed platformio.ini to allow build and upload directly #bugfix
2019-12-31 added instructions for PZDET and LOGIC to main.cpp #docs
2020-01-02 changed compiler to include help message only on 328pb #bugfix
2020-01-06 added verbose output to PIO build flags
2020-01-11 fixed typo in link to uart pdf #docs
2020-01-11 Added wiring image for ezpz uart #docs
2020-01-16 Changed default state of I2C input macro to enabled #featureadd
2020-01-16 updated changelog for v2.2.1 #docs
2020-01-17 fixed syntax issue with version variable #bugfix
2020-01-17 updated internal version with latest commit #docs
2020-01-21 Added eagle source files for SingleDisk PCB adapters #featureadd
2020-01-21 updated eagle parts library to latest #featureadd
2020-01-21 gave singledisk pcb a bit more flex for better sensitivity #bugfix
2020-01-21 updated gitignore with eagle library temp files
2020-01-23 updated piezoPCB singledisk for better actuation #bugfix
2020-01-31 updated circuit explanation docs #docs
    addition to #45
2020-02-19 Separating declaration and definition - volatile
2020-02-26 Added installation tutorial for MPDM #docs
2020-02-26 added a little more info about gettin support to installation page #docs
2020-02-26 updated parts library with new logo and TH parts #featureadd
2020-02-26 added compiled firmware used on MPDM #featureadd
2020-03-27 Formatting
2020-03-29 Added i2c bridge sketch
2020-04-14 Added VCC switch to I2C
2020-04-27 fixed syntax error in pt100 page
2020-05-07 Added user-friendty VCC readings adjustment #featureadd Minor fixes to i2c #bugfix
2020-05-09 fixed incorrect annotation on one config #docs
2020-05-10 updated changelog for v2.3.0 #docs
2020-05-13 updated Pyr0-Piezo configuration instructions with new parameters #docs
2020-05-13 added links to MPDM install guide #docs
2020-05-13 switching to dark theme on docs site #docs
2020-05-13 added i2c command syntax to I2C page #docs
2020-05-21 added kitspace integration #featureadd
2020-05-21 added readme for business card, updated kitspace yaml
2020-05-22 added logo to Standalone pcb
2020-06-05 Added embedded model frames for creality #docs
2020-06-11 fixed typo in VSC extension name #docs
2020-06-14 added screenshot for AVRDUDESS procedure #docs
2020-06-14 added compiled release firmware v2.3.0_b93dbb6 #featureadd
2020-06-15 Added interpreter hashbang to python version script #bugfix
2020-06-15 added release v2.3.1 compiled firmware #featureadd
2020-06-19 updated firmware upload doc with firmware download links #docs
2020-06-19 resized discord widget #docs
2020-06-19 formatting fixes for firmware update page #docs
2020-07-06 removed unneeded flags, fixed #76 #bugfix
2020-07-06 added Q/A about singledisk adapter to FAQ #docs
2020-07-24 fixed formatting issue on changelog #docs
2020-07-24 new board v2.3.1 - Moves larger components to top of board #bugfix
    - also optimizes several silkscreens and trace routes
2020-07-28 added screenshots and details to railcore page #docs
2020-07-29 added Railcore to mounting page #docs
2020-07-30 added documentation page for wiring harnesses #docs
2020-07-30 formatting changes for table text in wiring harness page #docs
2020-08-02 changed input voltage max to 12v based on beta testing feedback #docs
    - also removed outdated wiring diagrams til they can be updated
2020-08-20 Added board files for EzPzEffector #featureadd
2020-08-20 added page for all Fusion360 sources (currently empty) #featureadd
2020-09-15 Added bypass jumper to allow powering EzPz direct from heater VCC #featureadd
2020-09-15 added fusion360 sources to resourced menu on docs site #docs
2020-09-25 added extra info to bootup messages. #docs #featureadd
2020-09-28 Added fully-supported section for Creality printers #docs
2020-09-29 New HW rev v2.3.2 - changes method for adjusting output voltage level #bugfix #featureadd
    - Switches back to L78## fixed voltage regulators as they perform much better at 24v
    - Changes the resistor array previously used by LM317 to adjust VCC to
    now adjust output signal voltage only
    - Added better thermals for VReg
    - Optimized several groundplanes and polys
2020-10-08 updated about section with I2C info #docs
2020-10-08 Changed wording of link to PrecisionPiezo (since design is no longer derivative #docs
2020-10-14 commented out some startup messages due to stack overflow #bugfix
2020-10-20 clarified a couple of sections of the tuning guide #docs
2021-08-26 Added compiled binary for v2.3.2, edited serial to reduce memory use #bugfix
2021-08-26 updated major version on python script #featureadd
2021-10-04 clarified a FAQ #docs
2022-02-07 Updated Readme to reflect new features
