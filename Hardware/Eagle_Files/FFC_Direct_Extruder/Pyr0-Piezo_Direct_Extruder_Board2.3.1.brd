# Repository pyr0ball/pyr0piezo

File README.md:

For more extensive documentation, refer to the [Docs Site](https://docs.pyroballpcbs.com) (source included in this repository)

Presenting...

---

# The Pyr0-Piezo Z-Axis Sensor

## What is this thing?

TL;DR: It's a litte circuit that turns your actual nozzle into a z-probe.

This is a Z-Probe Sensor for 3D Printers that utilizes a piezoelectric element (commonly a 20-27mm piezo disk used in musical pickups) to detect when the nozzle of the printer touches the bed. There have been other Z-Probes in the past that do this, but this is the first to incorporate an onboard microcontroller that automatically calibrates and balances the circuit. Previous piezo Z-Probes all required manual tuning to some extent, usually with tiny hard-to-use trimpots. Due to the mechanical and electrical characteristics of this type of sensor, it has several advantages over other Z-Probes:

- There are no offsets to configure or adjust
- It can be configured to emulate either a standard endstop, or any active-high Z-Probe
- It's not dependent on a specific type of bed or hotend
- The builtin signal filtering reduces the amount of false driggers dramatically compared to other piezo sensors.
- It's FAST. Delay between the piezo being actuated and the z-trigger signal being sent to the printer's controller is ***just 26 nanoseconds***

### Is there a catch?

Well, yeah a couple. The sensor requires introducing a small amount of physical instability into the construction of the 3D printer. Something needs to move, even a small fraction of a millimeter. This can be something like the bed being pushed down slightly on it's springs, or adding a hinge and a tensioning spring to the print head. There's innumerable ways to make this work, and I've been working hard with my beta testers to find the best possible method combining as much stability as possble with the highest sensitivity. The other catch is that any oozing filament will skew the leveling results, so you have to decide to either assume there will always be ooze and use a small z-offset, or add a nozzle wipe/clean manuver to your startup gcode before bed leveling.

### How do I use it?

I designed the sensor to connect to a 3D Printer's controller like any other endstop or Z-Probe. The sensor also includes an i2c interface that will allow the 3D Printer's controller to change parameters on the fly depending on the use-case.

The piezo element is mounted somewhere on the 3D Printer in such a way that it undergoes mechanical stress when the nozzle touches the bed. So far there have been three distinct mounting schemes that appear to work well:

- On the extruder assembly
- Under the Print Bed
- In the case of CoreXY or other Gantry Kinematic systems, on either end of the gantry

#### Features:

- Self-calibrating (no more fiddling with tiny potentiometers!)
- Ultra-precise z-height measurements
- Zero offset (The nozzle itself is the sensor!)
- Compatible with ALL surface types
- No plugging in removable sensors for leveling
- Tunable over UART / I2C

#### FFC Cable Chain Extra Features:

- FFC Cable chain for a clean connection between print head and controller
- Onboard switchable DC buck converter for 12v or 5v fan operation
- LED Feedback on all PWM components
 Standalone version available for drop-in installation

Credit must be given to precisionpiezo.co.uk for getting me started on this project and giving me a place to start. I did build a version of the FFC cable chain based on their electrical designs but found the calibration of the circuit to be very fiddly, as the range of value on the potentiometers that was acceptable was very narrow.

I've since started from scratch using my own BOM and designs, while including an onboard microcontroller to handle auto-calibration. Given that every 3D printer is different, I wanted this sensor to be as easy and stable as other sensors available on the market, but with the increased performance of a piezo sensor.

Join our discord for support and to join in realtime discussion for the project:

---

## Contribution:

Please submit all Pull Requests through the **develop** branch!

The support site for this project uses a script to automatically parse git commits for changelog data. There are three categories of commits that should show up in the case log:

- Bugfix `#bugfix`: commits related to fixing something that's broken
- Added Features `#featureadd`: Commits related to adding new functions and features
- Documentation `#docs`: Any commits that deal specifically with the [documentation site](https://docs.pyroballpcbs.com) or comments/instructions contained within the source itself but do not contribute any functional changes

Simply by adding the corresponding tag to the end of the first line of your commit message, the changelog will automatically compile these for the documentation site. Please be sure to include this in any commit messages for this project.

I would also request that commits remain small, adding each change/fix/feature to their own commits. This will help with future debugging, version tracking, and testing.

---

This is a complete redesign from the ground up, but was inspired by the sensor developed by [PrecisionPiezoUK](https://precisionpiezo.co.uk/resources-osh)

Original FFC Cable Chain designs can be found on my Thingiverse:

- [3D Printed Mount for Prusa/Anet printers](https://www.thingiverse.com/thing:2712439)
- [FFC Cable Chain + Piezo boards](https://www.thingiverse.com/thing:2618717)

 Please refer to LICENSE.md for license information

## EAGLE design Hardware/Eagle_Files/FFC_Direct_Extruder/Pyr0-Piezo_Direct_Extruder_Board2.3.1.brd

Parts:
5V: TPTP13SQ; TP13SQ
+5V: TPTP13SQ; TP13SQ
C1: 0.1uF; CAPC2012X130
C2, C8, C9, C10, C11, C14: 0.1uF; CAPC1005X50
C3: 1uF; CAPC1609X80
C4, C6: 10uF; CAPC1005X50
C5, C7: 3.3uF; CAPC1609X80
C12: 1uF; CAPC1005X50
C13: 10nF; CAPC1005X50
COMP_PWM: TPTP09R; TP09R
D1: DIODE_ZENER_PLZ5V1C; DO-219AC
D2: LED-RGB-COM_ANO4PLCC; 4PLCC
D3, D4, D5: SEEED-LED_SMD-LED-CLEAR-BLUE(0603)LED_0603; SEEED-LED_LED-0603
D8: BAV199; SOT23
E0: C-GRID-04-70553; 70553-04
F1: 500mA; SEEED-RESISTOR_R0603
FAN0, FAN1: CON-MOLEX-2P-1.27MM048; 53048-02
FOL: TPTP13SQ; TP13SQ
FOL_PWM: TPTP09R; TP09R
GND: TPTP13SQ; TP13SQ
GOUT: TPTP13SQ; TP13SQ
H1, H2, H3: HOLES_MOUNT-PAD-ROUND3.2; HOLES_3,2-PAD
HE0: JST-2.54-2X2JST-DUPONT-2.54-2X2; HDRRAR4W64P254_2X2_556X736X556B
INT: TPTP13R; TP13R
J1: FFC-15P-1MM
MISO: TPTP13SQ; TP13SQ
MOSI: TPTP13SQ; TP13SQ
PT100: CON-MOLEX-2P-1.27MM048; 53048-02
PZ1: CON-MOLEX-3P-1.25MM048; 53048-03
PZ+: TPTP13SQ; TP13SQ
R1, R19: 1M; R0402
R2, R7, R10, R11: 10K; R0402
R3, R12, R14: 2K2; R0402
R4: 1K; EXBN8V
R5: 0R; R0402
R6, R8: 4K7; R0402
R9: 1K; R0402
R13, R15, R16: 100R; R0402
RST, RST.: TPTP13SQ; TP13SQ
RXD: TPTP13SQ; TP13SQ
SCK: TPTP13SQ; TP13SQ
SS: TPTP06R; TP06R
TH0: CON-MOLEX-2P-1.27MM048; 53048-02
TRG: SEEED-LED_SMD-LED-CLEAR-BLUE(0603)LED_0603; SEEED-LED_LED-0603
TXD: TPTP13SQ; TP13SQ
U1: ATMEGA48/88/168/328PB; QFN50P500X500X90-33N
U4: LM2902QT; QFN16
VCOM: TPTP13SQ; TP13SQ
X1: FFC-40P-0.5SH; FH12-40S-0.5SH
⏚: TPTP13SQ; TP13SQ

Connections:
+5V: +5V.TP, C1.1, D8.2 (C), F1.2, R3.1, R8.1, R16.2, U1.4 (VCC), U1.18 (AVCC)
COMP_VCC: C14.2, R16.1, U4.2 (V+)
E0_1A: E0.2, X1.37 (1), X1.38 (1)
E0_1B: E0.1, X1.39 (1), X1.40 (1)
E0_2A: E0.3, X1.35 (1), X1.36 (1)
E0_2B: E0.4, X1.33 (1), X1.34 (1)
ERR_LED: D2.P$2 (RED), U1.2 (PD4/XCK0/T0/PTCXY)
FAN0_GATE: D5.-, FAN0.1, X1.10 (1)
FAN1_GATE: D4.-, FAN1.1, X1.11 (1)
GADJ_R0: R4.2 (1), R4.8 (2), U1.7 (PB6/XTAL1/TOSC1)
GADJ_R1: R4.3 (1), R4.7 (2), U1.8 (PB7/XTAL2/TOSC2)
GADJ_R2: R4.4 (1), R4.6 (2), U1.9 (PD5/OC0B/T1/PTCXY)
GADJ_R3: R4.5 (2), R9.2, U1.10 (PD6/OC0A/PTCXY/AIN0)
GAIN_FB: R2.1, R4.1, U4.13 (-IN)
GAIN_OUT: GOUT.TP, R1.2, R2.2, U4.14 (OUT), U4.16 (-IN)
GND: C1.2, C2.1, C3.2, C4.1, C5.1, C6.1, C7.1, C9.1, C11.1, C13.1, C14.1, D1.P$1 (A), D2.P$3 (GRN), D8.1 (A), GND.TP, H1.B3,2, H2.B3,2, H3.B3,2, J1.P$1, J1.P$4, J1.P$9, J1.P$16 (TP), J1.P$17 (TP), PZ1.2, R9.1, R14.1, R19.1, TRG.+, U1.5 (GND0), U1.21 (GND1), U1.33 (PAD), U4.11 (V-), X1.1, X1.2 (1), X1.3 (1), X1.4 (1), X1.5 (1), X1.6 (1), X1.7 (1), X1.31 (1), X1.32 (1), ⏚.TP
HE0-: D3.-, HE0.3, HE0.4, J1.P$5, J1.P$6, J1.P$7, J1.P$8
LED_VCC: D3.+, D4.+, D5.+, R3.2
PT100+: C8.1, PT100.2, R7.2, R12.1
PT100-: C9.2, PT100.1, R11.2, R14.2
PT100_AMP+: C10.1, C12.2, R7.1, U4.4 (+IN)
PT100_AMP-: C11.2, C12.1, R11.1, U4.5 (-IN)
PT100_OUT: C13.2, R15.1, X1.12 (1), X1.13 (1)
PT100_R: R15.2, U4.6 (OUT)
PZ+: D8.3 (AC), PZ1.1, PZ+.TP, R19.2, U4.12 (+IN)
PZ_AMP_OUT: R13.1, U4.15 (OUT)
PZ_DET: PZ1.3, U1.25 (PC2/ADC2/PTCY)
RGB_VCC: D2.P$1 (ANO), R8.2
RST: RST.TP, RST..TP, U1.29 (PC6/!RESET!), X1.18 (1)
SCL: U1.6 (PE1/SCL1/T4/PTCXY), X1.21 (1)
SDA: U1.3 (PE0/SDA1/ICP4/ACO/PTCXY), X1.22 (1)
SPI_MISO: MISO.TP, U1.16 (PB4/MISO0/RXD1/PTCXY)
SPI_MOSI: MOSI.TP, U1.15 (PB3/MOSI0/TXD1/OC2A/PTCXY)
SPI_SCK: SCK.TP, U1.17 (PB5/PTCXY/XCK1/SCK0)
SPI_SS: SS.TP, U1.14 (PB2/!SS0!/OC1B/PTCXY)
TH0+: TH0.1, X1.8 (1)
TH0-: TH0.2, X1.9 (1)
TRG_LED: R6.2, TRG.-
TTL_RXD: RXD.TP, U1.30 (PD0/PTCXY/OC3A/RXD0), X1.19 (1)
TTL_TXD: TXD.TP, U1.31 (PD1/PTCXY/OC4A/TXD0), X1.20 (1)
VCC: HE0.1, HE0.2, J1.P$10, J1.P$11, J1.P$12, J1.P$13, J1.P$14, J1.P$15
VCC_REG: 5V.TP, C2.2, C8.2, C10.2, D1.P$2 (C), F1.1, R12.2, X1.16 (1), X1.17 (1)
VCOMP_PWM: COMP_PWM.TP, R5.2, U1.13 (PB1/OC1A/PTCXY)
VCOMP_SENSE: C6.2, C7.2, R5.1, U1.24 (PC1/ADC1/PTCY/SCK1), U4.1 (+IN), VCOM.TP
VREF_IN: C4.2, C5.2, FOL.TP, R10.1, U4.9 (+IN)
V_FOLLOW: R1.1, U1.23 (PC0/ADC0/PTCY/MISO1), U4.7 (OUT), U4.8 (-IN)
V_FOL_PWM: FOL_PWM.TP, R10.2, U1.1 (PD3/OC2B/INT1/PTCXY)
V_INT: C3.1, FAN0.2, FAN1.2, J1.P$2, J1.P$3
X_1A: X1.27 (1), X1.28 (1)
X_1B: X1.29 (1), X1.30 (1)
X_2A: X1.25 (1), X1.26 (1)
X_2B: X1.23 (1), X1.24 (1)
X_MIN_TRIG: X1.14 (1)
Z_MIN_TRIG: D2.P$4 (BLU), R6.1, U1.11 (PD7/PTCXY/AIN1), X1.15 (1)
Z_TRG: INT.TP, R13.2, U1.32 (PD2/PTCXY/INT0/OC3B/OC4B)

Notes on the sheet:
ATMega88/168/328
Power
LED's
Holes
Piezo Amp Circuit
Test Points
Connectors
VRef Buffer
Voltage Comparator DAC
Comparator
Piezo In
Amplifier Stage
8-bit PWM + LPF
- +
Gain Factor Adjust Ladder

Board: 2 copper layers, 42.6 x 46.5 mm, 73 parts (17 on the bottom side), 54 nets.

Other parts of the board:
U$1: LOGO-PYR0BALL-SS-20MM

## EAGLE design Hardware/Eagle_Files/EasyPiezi/EasyPiezi_2.3.2.brd

Parts:
5V: TPTP13SQ; TP13SQ
+5V: TPTP13SQ; TP13SQ
C1, C2: 1uF; CAPC1609X80
C3, C4, C5, C6, C8, C9, C10: 0.1uF; CAPC1005X50
C7: 1uF; CAPC1005X50
C11: 10nF; CAPC1005X50
C12, C14: 10uF; CAPC1005X50
C13, C15: 3.3uF; CAPC1005X50
C_PWM: TPTP06R; TP06R
D1: DIODE_ZENER_PLZ5V1C; DO-219AC
D8: BAV199; SOT23
F1: 500mA; R0402
FOL: TPTP13SQ; TP13SQ
F_PWM: TPTP09R; TP09R
GND: TPTP13SQ; TP13SQ
GOUT: TPTP13SQ; TP13SQ
H2, H3: HOLES_MOUNT-PAD-ROUND3.2; HOLES_3,2-PAD
INT: TPTP06R; TP06R
J1: CON-MOLEX-6P-1.25MM048; 53048-06
J2: SEEED-RESISTOR_SMD-RES-1.5K-1%-1/10W(0603)DETAILE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; SEEED-RESISTOR_R0603
LED: LED-RGB-COM_ANO0606; 0606_LED
MISO: TPTP13SQ; TP13SQ
MOSI: TPTP13SQ; TP13SQ
PT100: CON-MOLEX-2P-1.27MM048; 53048-02
PT+: TPTP09R; TP09R
PT-: TPTP09R; TP09R
PZ1: CON-MOLEX-3P-1.25MM048; 53048-03
PZ+: TPTP13SQ; TP13SQ
R1, R4: 1M; R0402
R2, R19, R20: 2K2; R0402
R3, R7, R10, R17, R18: 10K; R0402
R5, R8: 3K3; R0402
R9: 3K6; R0402
R14: 1K; R0402
R15, R21, R22: 100R; R0402
RDY: SEEED-LED_SMD-LED-CLEAR-BLUE(0603)LED_0603; SEEED-LED_LED-0603
RP1: 1K; EXBN8V-L
RST, RST.: TPTP13SQ; TP13SQ
RXD: TPTP13SQ; TP13SQ
SCK: TPTP13SQ; TP13SQ
SJ1: SJ
TP_F: TPTP09R; TP09R
TXD: TPTP13SQ; TP13SQ
U1: ATMEGA48/88/168/328PB; QFN50P500X500X90-33N
U2: L78L05ACU; SOT89
U3: LM2902QT; QFN16
VCOM: TPTP13SQ; TP13SQ
⏚: TPTP13SQ; TP13SQ

Connections:
+5V: 5V.TP, +5V.TP, C1.2, C3.2, C4.2, C5.2, C8.2, D1.P$2 (C), D8.2 (C), R8.1, R19.2, R21.2, SJ1.2, U1.4 (VCC), U1.18 (AVCC), U2.1 (OUT)
AMP_VCC: C10.2, R21.1, U3.2 (V+)
ERR_LED: LED.P$1 (RED), U1.2 (PD4/XCK0/T0/PTCXY)
GADJ_R0: RP1.2 (1), RP1.8 (2), U1.7 (PB6/XTAL1/TOSC1)
GADJ_R1: RP1.3 (1), RP1.7 (2), U1.8 (PB7/XTAL2/TOSC2)
GADJ_R2: RP1.4 (1), RP1.6 (2), U1.9 (PD5/OC0B/T1/PTCXY)
GADJ_R3: R14.2, RP1.5 (2), U1.10 (PD6/OC0A/PTCXY/AIN0)
GAIN_ADJ: R3.1, RP1.1, U3.8 (-IN)
GAIN_OUT: GOUT.TP, R3.2, R4.1, U3.7 (OUT), U3.16 (-IN)
GND: C1.1, C2.1, C3.1, C4.1, C6.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, D1.P$1 (A), D8.1 (A), GND.TP, H2.B3,2, H3.B3,2, J1.3, LED.P$3 (GRN), PZ1.2, R1.1, R14.1, R20.1, RDY.-, U1.5 (GND0), U1.21 (GND1), U1.33 (PAD), U2.2 (GND), U2.PAD, U3.11 (V-), ⏚.TP
LED_PWR: LED.P$2 (ANO), R8.2
PT100_JUMP: C11.2, J2.1, R22.2
PT100_OUT: J1.6, J2.2
PT_AMP: R22.1, U3.6 (OUT)
PT_AMP+: C7.2, C8.1, R17.2, U3.4 (+IN)
PT_AMP-: C7.1, C9.2, R18.2, U3.5 (-IN)
PT_IN+: C5.1, PT100.1, PT+.TP, R17.1, R19.1
PT_IN-: C6.2, PT100.2, PT-.TP, R18.1, R20.2
PZ+: D8.3 (AC), PZ1.1, PZ+.TP, R1.2, U3.9 (+IN)
PZ_AMP_OUT: R15.1, U3.15 (OUT)
PZ_DET: PZ1.3, U1.25 (PC2/ADC2/PTCY)
RDY_LED: R5.2, RDY.+
RST: RST.TP, RST..TP, U1.29 (PC6/!RESET!)
SCL: J1.2, U1.6 (PE1/SCL1/T4/PTCXY)
SDA: J1.1, U1.3 (PE0/SDA1/ICP4/ACO/PTCXY)
SIG_ADJ: R2.1, U1.12 (PB0/ICP1/CLKO/PTCXY)
SPI_MISO: MISO.TP, U1.16 (PB4/MISO0/RXD1/PTCXY)
SPI_MOSI: MOSI.TP, U1.15 (PB3/MOSI0/TXD1/OC2A/PTCXY)
SPI_SCK: SCK.TP, U1.17 (PB5/PTCXY/XCK1/SCK0)
TTL_RXD: RXD.TP, U1.30 (PD0/PTCXY/OC3A/RXD0)
TTL_TXD: TXD.TP, U1.31 (PD1/PTCXY/OC4A/TXD0)
VCC_FUSE: F1.2, SJ1.1, U2.3 (IN)
VCC_REG: C2.2, F1.1, J1.4
VCOMP_PWM: C_PWM.TP, R7.1, U1.13 (PB1/OC1A/PTCXY)
VCOMP_SENSE: C14.2, C15.2, R7.2, U1.24 (PC1/ADC1/PTCY/SCK1), U3.1 (+IN), VCOM.TP
V_FOLLOW: R4.2, TP_F.TP, U1.23 (PC0/ADC0/PTCY/MISO1), U3.13 (-IN), U3.14 (OUT)
V_FOL_ADJ: C12.2, C13.2, FOL.TP, R10.1, U3.12 (+IN)
V_FOL_PWM: F_PWM.TP, R10.2, U1.1 (PD3/OC2B/INT1/PTCXY)
Z_MIN_TRIG: LED.P$4 (BLU), R5.1, R9.1, U1.11 (PD7/PTCXY/AIN1)
Z_OUT: J1.5, R2.2, R9.2
Z_TRG: INT.TP, R15.2, U1.32 (PD2/PTCXY/INT0/OC3B/OC4B)

Notes on the sheet:
ATMega88/168/328
Power
LED's
Holes
Piezo Amp Circuit
Test Points
Connectors
PT100 Amp Circuit
Amplification Stage
Amp Gain Adjustment Ladder
Voltage Follower
Comparator

Board: 2 copper layers, 43.0 x 15.4 mm, 71 parts (33 on the bottom side), 41 nets.

Other parts of the board:
U$1, U$2: LOGO-PYR0BALL-SS-6MM

## EAGLE design Hardware/Eagle_Files/EzPzEffector/EzPz-Effector_v2.3.1.brd

Parts:
C1, C7: 1uF; C0603K
C2: 100uf; ALU-C-D5.3MM_RIGHT
C3, C4, C5, C6, C8, C9, C10: 0.1uF; C0603K
C11: 10nF; C0603K
C12, C14, C16: 10uF; C0603K
C13, C15: 3.3uF; C0603K
D1: DIODE_ZENER_PLZ5V1C; DO-219AC
D8: BAV199; SOT23
F1: 500mA; SEEED-RESISTOR_R0603
H1, H2, H3: EFFECTOR-ROD-MOUNT; EFFECTOR-45MM-ROD
HEATER: C-GRID-04-70543; 70543-04
ICSP: ICSP_HEADERICSP-2.54MM; ICSP_3X2_2.54_STRAIGHT
INT: TPTP06R; TP06R
J1: C-GRID-06-70543; 70543-06
LED: LED-RGB-COM_ANO0606; 0606_LED
PT100: C-GRID-02-70543; 70543-02
PZ1, PZ2, PZ3: PIEZO-DISK12MM-OFFSET; PIEZO-DISK-12MM-OFFSET
R1, R4: 1M; SEEED-RESISTOR_R0603
R2, R19, R20: 2K2; SEEED-RESISTOR_R0603
R3, R7, R10, R17, R18, R23: 10K; SEEED-RESISTOR_R0603
R5: 3K; SEEED-RESISTOR_R0603
R6, R8: 3K3; SEEED-RESISTOR_R0603
R9: 3K6; SEEED-RESISTOR_R0603
R11, R12, R13, R14, R16: 1K; SEEED-RESISTOR_R0603
R15, R21, R22: 100R; SEEED-RESISTOR_R0603
RDY: SEEED-LED_SMD-LED-CLEAR-BLUE(0603)LED_0603; SEEED-LED_LED-0603
SJ1: SJ
U1: ATMEGA328PTQFP-32; QFP80P900X900X120-32N
U2: LM317DCYSOT223; SOT230P700X180-4N
U3: LM2902PT; SSOP14
UART: JST-2.54MM_5P-2.54JST_2.54MM_5P_F; HDRVR5W64P254_1X5_1270X254X575B
V/TH_IN: 5566-4

Connections:
+5V: C1.2, C3.2, C4.2, C5.2, C8.2, D1.P$2 (C), D8.2 (C), ICSP.2 (VCC), R2.2, R8.1, R19.2, R21.2, R23.2, SJ1.2, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U2.2 (OUTPUT_2), U2.4 (OUTPUT), UART.1
AMP_VCC: C10.2, R21.1, U3.4 (V+)
ERR_LED: LED.P$1 (RED), U1.2 ((PCINT20/XCK/T0)_PD4)
GADJ_R0: R14.1, R16.2, U1.7 ((PCINT6/XTAL1/TOSC1)_PB6)
GADJ_R1: R13.1, R14.2, U1.8 ((PCINT7/XTAL2/TOSC2)_PB7)
GADJ_R2: R12.1, R13.2, U1.9 ((PCINT21/OC0B/T1)_PD5)
GADJ_R3: R11.2, R12.2, U1.10 ((PCINT22/OC0A/AIN0)_PD6)
GAIN_ADJ: R3.1, R16.1, U3.9 (-IN)
GAIN_OUT: R3.2, R4.2, U3.2 (-IN), U3.8 (OUT)
GND: C1.1, C2.-, C3.1, C4.1, C6.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, D1.P$1 (A), D8.1 (A), H1.P$1, H1.P$2, H2.P$1, H2.P$2, H3.P$1, H3.P$2, ICSP.6 (GND), J1.3, LED.P$3 (GRN), PZ1.GND1 (GND), PZ1.GND2 (GND), PZ1.GND3 (GND), PZ2.GND1 (GND), PZ2.GND2 (GND), PZ2.GND3 (GND), PZ3.GND1 (GND), PZ3.GND2 (GND), PZ3.GND3 (GND), R1.1, R9.1, R11.1, R20.1, RDY.-, U1.3 (GND), U1.5 (GND), U1.21 (GND), U3.11 (V-), UART.2
HE0-: HEATER.4, V/TH_IN.2
LED_PWR: LED.P$2 (ANO), R8.2
PT100_OUT: C11.2, J1.6, R22.2
PT_AMP: R22.1, U3.7 (OUT)
PT_AMP+: C7.2, C8.1, R17.2, U3.5 (+IN)
PT_AMP-: C7.1, C9.2, R18.2, U3.6 (-IN)
PT_IN+: C5.1, PT100.2, R17.1, R19.1
PT_IN-: C6.2, PT100.1, R18.1, R20.2
PZ+: D8.3 (AC), PZ1.PZ+, PZ2.PZ+, PZ3.PZ+, R1.2, U3.10 (+IN)
PZ_AMP_OUT: R15.1, U3.1 (OUT)
PZ_DET: U1.25 (PC2_(ADC2/PCINT10))
RDY_LED: R6.2, RDY.+
REG_ADJ: R2.1, R5.1, U2.1 (ADJUST)
RST: C16.1, ICSP.5 (RST), U1.29 (PC6_(RESET/PCINT14))
SCL: J1.2, U1.28 (PC5_(ADC5/SCL/PCINT13))
SDA: J1.1, U1.27 (PC4_(ADC4/SDA/PCINT12))
SPI_MISO: ICSP.1 (MISO), U1.16 ((PCINT4/MISO)_PB4)
SPI_MOSI: ICSP.3 (MOSI), U1.15 ((PCINT3/OC2A/MOSI)_PB3)
SPI_SCK: ICSP.4 (SCK), U1.17 (PB5_(SCK/PCINT5))
TH0: HEATER.3, V/TH_IN.1
TH1: HEATER.2, V/TH_IN.3
TTL_DTR: C16.2, R23.1, UART.5
TTL_RXD: U1.30 (PD0_(RXD/PCINT16)), UART.4
TTL_TXD: U1.31 (PD1_(TXD/PCINT17)), UART.3
VCC_ADJ: R5.2, R9.2, U1.12 ((PCINT0/CLKO/ICP1)_PB0)
VCC_FUSE: F1.2, SJ1.1, U2.3 (INPUT)
VCC_REG: C2.+, F1.1, J1.4; also elsewhere on the board
VCOMP_PWM: R7.1, U1.13 ((PCINT1/OC1A)_PB1)
VCOMP_SENSE: C14.2, C15.2, R7.2, U1.24 (PC1_(ADC1/PCINT9)), U3.3 (+IN)
VIN_12/24: HEATER.1, V/TH_IN.4; also elsewhere on the board
V_FOLLOW: R4.1, U1.23 (PC0_(ADC0/PCINT8)), U3.13 (-IN), U3.14 (OUT)
V_FOL_ADJ: C12.2, C13.2, R10.2, U3.12 (+IN)
V_FOL_PWM: R10.1, U1.1 ((PCINT19/OC2B/INT1)_PD3)
Z_MIN_TRIG: J1.5, LED.P$4 (BLU), R6.1, U1.11 ((PCINT23/AIN1)_PD7)
Z_TRG: INT.TP, R15.2, U1.32 (PD2_(INT0/PCINT18))

Notes on the sheet:
ATMega88/168/328
Power
LED's
Holes
Piezo Amp Circuit
Extruder Connections
Connectors
PT100 Amp Circuit
Amplification Stage
Amp Gain Adjustment Ladder
Voltage Follower
Comparator

Notices in the files:
Hardware/Eagle_Files/FFC_Direct_Breakout/Pyr0-Piezo_Direct-Extruder-FFC-Breakout_2.0.1.brd:
Copyright 2019 Alan "pyr0ball" Weinstock
