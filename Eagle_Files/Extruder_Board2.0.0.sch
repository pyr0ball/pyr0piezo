File: Eagle_Files/Extruder_Board2.0.0.sch (EAGLE design)
At the start: 60 parts, among them J2 FFC_MOLEX_0.5MM, U1 ATMEGA48PA-MMHR28M1-L, U2 MCP6001T-I/OTSOT-23-5_MC-L, U3 LM358PWRDFN-8

Commit message: Brought FFC board up to v2.x spec.
Still ToDo: route traces for PT100 input to amp
Parts:
- removed A_OUT: TPTP10R, PiezoFFC:TPTP10R
- removed R17: 3.3K, PiezoFFC:SMD-RES-0R-5%-1/16W(0402)
- removed U2: MCP6001T-I/OTSOT-23-5_MC-L, PiezoFFC:MCP6001T-I/OTSOT-23-5_MC-L
- removed U3: LM358PWRDFN-8, PiezoFFC:LM358PWRDFN-8
- added C10, C11, C8, C9: 0.1uF, PiezoFFC:CERAMIC-1NF-50V-10%-X7R(0402)CAP_0402
- added C12: 1uF, PiezoFFC:CERAMIC-1NF-50V-10%-X7R(0402)CAP_0402
- added C13: 10nF, PiezoFFC:CERAMIC-1NF-50V-10%-X7R(0402)CAP_0402
- added C4, C6: 10uF, PiezoFFC:CERAMIC-1NF-50V-10%-X7R(0402)CAP_0402
- added C5, C7: 3.3uF, PiezoFFC:SEEED-CAPACITOR_CERAMIC-10UF-25V-10%-X5R(0805)CAP_0603_GEN
- added PT100: CON-MOLEX-2P-1.27MM048, PiezoFFC:CON-MOLEX-2P-1.27MM048
- added PZ+: TPTP13SQ, PiezoFFC:TPTP13SQ
- added R14: 2K2, PiezoFFC:SMD-RES-0R-5%-1/16W(0402)
- added U4: LM2902QT, PiezoFFC:LM2902QT
- ADJ+, ADJ-: value TPTP10R -> TPTP13SQ; device PiezoFFC:TPTP10R -> PiezoFFC:TPTP13SQ
- D1: value 1N4148DFN-1006-2 -> ZENER_DIODE_PLZ5V1C; device PiezoFFC:1N4148DFN-1006-2 -> PiezoFFC:ZENER_DIODE_PLZ5V1C
- H1, H2, H3: value HOLES_MOUNT-PAD-ROUND2.8 -> HOLES_MOUNT-PAD-ROUND3.2; device PiezoFFC:HOLES_MOUNT-PAD-ROUND2.8 -> PiezoFFC:HOLES_MOUNT-PAD-ROUND3.2
- R11, R7: value 220R -> 10K
- R12: value 330R -> 2K2
- R15: value 680R -> 100R
- R4: value 10K -> 1K; device PiezoFFC:SMD-RES-0R-5%-1/16W(0402) -> PiezoFFC:RESISTOR_NETWORK_X40804
- R5: value 330R -> 10K; device PiezoFFC:SMD-RES-0R-5%-1/16W(0402) -> PiezoFFC:SEEED-RESISTOR_SMD-RES-1.5K-1%-1/10W(0603)DETAILED_MODEL
- R6: value (none) -> 4.7k
- R9: value 470R -> 1K
Connections:
- removed net COMP-: ADJ+.TP, R1.2, R2.2, U2.VOUT, U3A.1IN-
- removed net VADJ_R0: R11.2, R7.1, U1A.(PCINT6/XTAL1/TOSC1)_PB6
- removed net VADJ_R1: R11.1, R12.2, U1A.(PCINT7/XTAL2/TOSC2)_PB7
- removed net VADJ_R2: R12.1, R5.2, U1A.(PCINT21/OC0B/T1)_PD5
- removed net VADJ_R3: R5.1, R9.2, U1A.(PCINT22/OC0A/AIN0)_PD6
- removed net VADJ_SENSE: ADJ-.TP, R15.2, R7.2, U1A.PC1_(ADC1/PCINT9), U3A.1IN+
- removed net V_FOLLOW: R1.1, U1A.PC0_(ADC0/PCINT8), U3B.2IN-, U3B.2OUT
- new net GADJ_R0: R4A.2, R4B.1, U1A.(PCINT6/XTAL1/TOSC1)_PB6
- new net GADJ_R1: R4B.2, R4C.1, U1A.(PCINT7/XTAL2/TOSC2)_PB7
- new net GADJ_R2: R4C.2, R4D.1, U1A.(PCINT21/OC0B/T1)_PD5
- new net GADJ_R3: R4D.2, R9.2, U1A.(PCINT22/OC0A/AIN0)_PD6
- new net GAIN_OUT: ADJ-.TP, R1.2, R2.2, U4A.-IN, U4D.OUT
- new net PT100+: C8.1, PT100-1.S, R12.1, R7.2
- new net PT100-: C9.2, PT100-2.S, R11.2, R14.2
- new net PT100_AMP+: C10.1, C12.2, R7.1, U4B.+IN
- new net PT100_AMP-: C11.2, C12.1, R11.1, U4B.-IN
- new net PT100_OUT: C13.2, R15.1
- new net PT100_R: R15.2, U4B.OUT
- new net VCOMP_PWM: R5.2, U1A.(PCINT1/OC1A)_PB1
- new net VCOMP_SENSE: ADJ+.TP, C6.2, C7.2, R5.1, U1A.PC1_(ADC1/PCINT9), U4A.+IN
- new net V_FOL_PWM: R10.2, U1A.(PCINT19/OC2B/INT1)_PD3
- new net V_FOL_SENSE: R1.1, U1A.PC0_(ADC0/PCINT8), U4C.-IN, U4C.OUT
- net +5V: now also U4P.V+; no longer R10.2, R15.1, U2.VDD, U3A.VCC
- net ERR_LED: now also U1A.(PCINT20/XCK/T0)_PD4; no longer U1A.(PCINT19/OC2B/INT1)_PD3
- net GAIN_FB: now also R4A.1, U4D.-IN; no longer R17.2, U2.VIN-
- net GND: now also C11.1, C13.1, C4.1, C5.1, C6.1, C7.1, C9.1, PZ1-2.S, R14.1, U4P.V-; no longer PZ1-1.S, R17.1, R4.1, U2.VSS, U3A.GND
- net PZ+: now also PZ+.TP, PZ1-1.S, U4D.+IN; no longer PZ1-2.S, U2.VIN+
- net PZ_AMP_OUT: now also U4A.OUT; no longer A_OUT.TP, U3A.1OUT
- net RST: now also J2.44
- net SCL: now also J2.47
- net SDA: now also J2.48
- net TTL_RXD: now also J2.45
- net TTL_TXD: now also J2.46
- net VCC_REG: now also C10.2, C8.2, R12.2
- net VREF_IN: now also C4.2, C5.2, U4C.+IN; no longer R4.2, U3B.2IN+
- net Z_MIN_TRIG: now also U1A.(PCINT23/AIN1)_PD7; no longer U1A.(PCINT1/OC1A)_PB1
Other:
- note added: "8-bit PWM + LPF"
- note added: "Amplifier Stage"
- note added: "Gain Factor Adjust Ladder"
- note added: "Voltage Comparator DAC"
- note removed: "2.50V +/- 20mV"
- note removed: "Amplifier - 3X Gain"
- note removed: "Auto Adjust Ladder"
- moved on the sheet: ADJ+, ADJ-, C1, D8, PZ1-1, PZ1-2, R1, R10, R11, R12, R13, R15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

Commit message: Added pin assignments for serial/i2c comms on FFC
Builds necessary back-channel for https://github.com/pyr0ball/pyr0piezo/issues/2
Also added pin assignments used in https://github.com/pyr0ball/pyr0piezo/issues/18
Connections:
- new net X_1A: J2.53, J2.54
- new net X_1B: J2.55, J2.56
- new net X_2A: J2.51, J2.52
- new net X_2B: J2.49, J2.50
- new net X_MIN_TRIG: J2.40
- net PT100_OUT: now also J2.39
- net Z_MIN_TRIG: now also J2.41; no longer J2.56
Changed lines of the file:
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@@
 <setting verticaltext="up"/>
 </settings>
-<grid distance="1.27" unitdist="mm" unit="mm" style="lines" multiple="1" display="no" altdistance="0.127" altunitdist="mm" altunit="mm"/>
+<grid distance="0.1" unitdist="inch" unit="inch" style="lines" multiple="1" display="no" altdistance="0.01" altunitdist="inch" altunit="inch"/>
 <layers>
 <layer number="1" name="Top" color="4" fill="1" visible="no" active="no"/>
@@
 <net name="Z_MIN_TRIG" class="0">
 <segment>
-<wire x1="355.6" y1="78.74" x2="370.84" y2="78.74" width="0.1524" layer="91"/>
-<label x="370.84" y="78.74" size="1.778" layer="95" rot="R180"/>
-<pinref part="J2" gate="G$1" pin="56"/>
+<label x="358.14" y="116.84" size="1.778" layer="95"/>
+<pinref part="J2" gate="G$1" pin="41"/>
+<wire x1="373.38" y1="116.84" x2="355.6" y2="116.84" width="0.1524" layer="91"/>
 </segment>
 <segment>
@@
 <junction x="265.43" y="41.91"/>
 </segment>
-</net>
+<segment>
+<pinref part="J2" gate="G$1" pin="39"/>
+<wire x1="355.6" y1="121.92" x2="370.84" y2="121.92" width="0.1524" layer="91"/>
+<label x="358.14" y="121.92" size="1.778" layer="95"/>
+</segment>
+</net>
+<net name="X_1B" class="0">
+<segment>
+<pinref part="J2" gate="G$1" pin="56"/>
+<wire x1="355.6" y1="78.74" x2="358.14" y2="78.74" width="0.1524" layer="91"/>
+<wire x1="358.14" y1="78.74" x2="358.14" y2="81.28" width="0.1524" layer="91"/>
+<pinref part="J2" gate="G$1" pin="55"/>
+<wire x1="358.14" y1="81.28" x2="355.6" y2="81.28" width="0.1524" layer="91"/>
+<wire x1="358.14" y1="81.28" x2="370.84" y2="81.28" width="0.1524" layer="91"/>
+<junction x="358.14" y="81.28"/>
+<label x="365.76" y="81.28" size="1.778" layer="95"/>
+</segment>
+</net>
+<net name="X_1A" class="0">
+<segment>
+<pinref part="J2" gate="G$1" pin="53"/>
+<wire x1="355.6" y1="86.36" x2="358.14" y2="86.36" width="0.1524" layer="91"/>
+<pinref part="J2" gate="G$1" pin="54"/>
+<wire x1="358.14" y1="86.36" x2="370.84" y2="86.36" width="0.1524" layer="91"/>
+<wire x1="355.6" y1="83.82" x2="358.14" y2="83.82" width="0.1524" layer="91"/>
+<wire x1="358.14" y1="83.82" x2="358.14" y2="86.36" width="0.1524" layer="91"/>
+<junction x="358.14" y="86.36"/>
+<label x="365.76" y="86.36" size="1.778" layer="95"/>
+</segment>
+</net>
+<net name="X_2A" class="0">
+<segment>
+<pinref part="J2" gate="G$1" pin="51"/>
+<wire x1="355.6" y1="91.44" x2="358.14" y2="91.44" width="0.1524" layer="91"/>
+<pinref part="J2" gate="G$1" pin="52"/>
+<wire x1="358.14" y1="91.44" x2="370.84" y2="91.44" width="0.1524" layer="91"/>
+<wire x1="355.6" y1="88.9" x2="358.14" y2="88.9" width="0.1524" layer="91"/>
+<wire x1="358.14" y1="88.9" x2="358.14" y2="91.44" width="0.1524" layer="91"/>
+<junction x="358.14" y="91.44"/>
+<label x="365.76" y="91.44" size="1.778" layer="95"/>
+</segment>
+</net>
+<net name="X_2B" class="0">
+<segment>
+<pinref part="J2" gate="G$1" pin="49"/>
+<wire x1="355.6" y1="96.52" x2="358.14" y2="96.52" width="0.1524" layer="91"/>
+<pinref part="J2" gate="G$1" pin="50"/>
+<wire x1="358.14" y1="96.52" x2="370.84" y2="96.52" width="0.1524" layer="91"/>
+<wire x1="355.6" y1="93.98" x2="358.14" y2="93.98" width="0.1524" layer="91"/>
+<wire x1="358.14" y1="93.98" x2="358.14" y2="96.52" width="0.1524" layer="91"/>
+<junction x="358.14" y="96.52"/>
+<label x="365.76" y="96.52" size="1.778" layer="95"/>
+</segment>
+</net>
+<net name="X_MIN_TRIG" class="0">
+<segment>
+<pinref part="J2" gate="G$1" pin="40"/>
+<wire x1="355.6" y1="119.38" x2="373.38" y2="119.38" width="0.1524" layer="91"/>
+<label x="358.14" y="119.38" size="1.778" layer="95"/>
+</segment>
+</net>
