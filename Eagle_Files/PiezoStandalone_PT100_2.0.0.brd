File: Eagle_Files/PiezoStandalone_PT100_2.0.0.brd (EAGLE design)
At the start: 43 x 15.4 mm, 71 parts, among them J1 CON-MOLEX-4P-1.25MM048, U1 ATMEGA48/88/168/328PA28M1-L, U2 L78L05ACU, U3 LM2902QT

Commit message: repositioned filter cap for easier soldering
Parts:
- moved C7 0.44 mm to (28.8, 4.22)
- moved C10 0.19 mm to (27.1, 3.17)
Routing:
- net PT_AMP+: track 12.9 -> 12.4 mm
